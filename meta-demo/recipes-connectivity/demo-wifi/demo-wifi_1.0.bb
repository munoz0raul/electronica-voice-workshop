SUMMARY = "Demo Wi-Fi network: hostapd access point and NetworkManager client"
DESCRIPTION = "VENTUNO Q runs a WPA2-PSK access point with hostapd and a DHCP \
server, and UNO Q joins it with NetworkManager, using the shared SSID and \
passphrase in wifi.conf."
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

# wifi.conf is generated by build-os.sh and not committed; see
# wifi.conf.example.
SRC_URI = " \
    file://wifi.conf \
    file://demo-wifi-client.nmconnection \
    file://demo-wifi-ap.hostapd.conf \
    file://demo-wifi-ap.service \
    file://demo-wifi-ap-run \
    file://demo-wifi-dhcp.service \
    file://demo-wifi-dnsmasq.conf \
    file://demo-wifi-mdns.service \
    file://demo-wifi-ap-unmanaged.conf \
    file://set-wlan-mac \
    file://70-wlan-mac.rules \
    file://demo-wifi-resolved.conf \
"
S = "${UNPACKDIR}"
COMPATIBLE_MACHINE = "^(uno-q|ventuno-q|iq-9075-evk)$"
PACKAGE_ARCH = "${MACHINE_ARCH}"

DEMO_WIFI_ROLE ?= "client"
DEMO_WIFI_ROLE:ventuno-q = "ap"
# The VENTUNO Q's QCA2066 (PCIe M.2) interface
DEMO_WIFI_AP_IFACE ?= "wlp3s0"
# Name for the VENTUNO Q on the demo network: published over mDNS by the AP
# and listed in /etc/hosts on both machines
DEMO_WIFI_SERVER_NAME ?= "demo-server.local"

inherit systemd
SYSTEMD_SERVICE:${PN} = ""
SYSTEMD_SERVICE:${PN}:ventuno-q = "demo-wifi-ap.service demo-wifi-dhcp.service demo-wifi-mdns.service"

do_install() {
    . ${UNPACKDIR}/wifi.conf

    if [ -z "${WIFI_SSID}" ] || [ ${#WIFI_SSID} -gt 32 ]; then
        bbfatal "wifi.conf: WIFI_SSID must be 1-32 characters"
    fi
    if [ ${#WIFI_PSK} -lt 8 ] || [ ${#WIFI_PSK} -gt 63 ]; then
        bbfatal "wifi.conf: WIFI_PSK must be 8-63 characters"
    fi

    escape() {
        printf '%s' "$1" | sed -e 's/[\\|&]/\\&/g'
    }

    address="${WIFI_AP_ADDRESS:-10.42.0.1/24}"
    if [ "${address#*/}" != "24" ]; then
        bbfatal "wifi.conf: WIFI_AP_ADDRESS must be a /24 address"
    fi
    ap_ip="${address%/*}"

    install -D -m 0644 ${UNPACKDIR}/demo-wifi-resolved.conf \
        ${D}${nonarch_libdir}/systemd/resolved.conf.d/50-demo-wifi.conf

    # The server name for /etc/hosts (see pkg_postinst): the UNO Qs have no
    # mDNS resolver, and the VENTUNO Q reaches its own update-server by it
    install -d ${D}${datadir}/demo-wifi
    printf '%s %s\n' "${ap_ip}" "${DEMO_WIFI_SERVER_NAME}" > ${D}${datadir}/demo-wifi/hosts

    if [ "${DEMO_WIFI_ROLE}" = "client" ]; then
        # /usr/lib profiles are part of the OSTree deployment, so OTA updates
        # replace them; NetworkManager ignores profiles not owned by root/0600.
        install -d ${D}${nonarch_libdir}/NetworkManager/system-connections
        sed -e "s|@SSID@|$(escape "${WIFI_SSID}")|g" \
            -e "s|@PSK@|$(escape "${WIFI_PSK}")|g" \
            ${UNPACKDIR}/demo-wifi-client.nmconnection \
            > ${D}${nonarch_libdir}/NetworkManager/system-connections/demo-wifi-client.nmconnection
        chmod 0600 ${D}${nonarch_libdir}/NetworkManager/system-connections/demo-wifi-client.nmconnection

        # Factory MAC from the eMMC instead of ath10k's random one
        install -D -m 0755 ${UNPACKDIR}/set-wlan-mac ${D}${libexecdir}/demo-wifi/set-wlan-mac
        install -D -m 0644 ${UNPACKDIR}/70-wlan-mac.rules \
            ${D}${nonarch_base_libdir}/udev/rules.d/70-wlan-mac.rules
        return
    fi

    case "${WIFI_BAND:-bg}" in
    bg)
        hwmode=g
        acs_channels="1 6 11"
        fallback_channel=6
        ;;
    a)
        hwmode=a
        # Non-DFS only: DFS channels need a radar check before the AP starts
        # and can force a channel change mid-demo
        acs_channels="36 40 44 48 149 153 157 161 165"
        fallback_channel=36
        ;;
    *) bbfatal "wifi.conf: WIFI_BAND must be bg or a" ;;
    esac
    channel="${WIFI_CHANNEL:-6}"
    case "$channel" in
    auto) ;;
    *[!0-9]* | "") bbfatal "wifi.conf: WIFI_CHANNEL must be a channel number or auto" ;;
    esac
    net="${ap_ip%.*}"

    subst() {
        sed -e "s|@SSID@|$(escape "${WIFI_SSID}")|g" \
            -e "s|@PSK@|$(escape "${WIFI_PSK}")|g" \
            -e "s|@COUNTRY@|$(escape "${WIFI_COUNTRY:-US}")|g" \
            -e "s|@HWMODE@|${hwmode}|g" \
            -e "s|@CHANNEL@|$([ "$channel" = auto ] && echo 0 || echo "$channel")|g" \
            -e "s|@IFACE@|${DEMO_WIFI_AP_IFACE}|g" \
            -e "s|@AP_ADDRESS@|${address}|g" \
            -e "s|@DHCP_RANGE@|${net}.10,${net}.254,12h|g" \
            -e "s|@SYSCONFDIR@|${sysconfdir}|g" \
            -e "s|@AP_IP@|${ap_ip}|g" \
            -e "s|@SERVER_NAME@|${DEMO_WIFI_SERVER_NAME}|g" \
            "$1" > "$2"
    }

    install -d -m 0700 ${D}${sysconfdir}/demo-wifi
    subst ${UNPACKDIR}/demo-wifi-ap.hostapd.conf ${D}${sysconfdir}/demo-wifi/hostapd.conf
    if [ "$channel" = auto ]; then
        # hostapd surveys the candidates at startup and picks the least busy
        printf '%s\n' "# WIFI_CHANNEL=auto: automatic channel selection (ACS)" \
            "acs_exclude_dfs=1" "chanlist=${acs_channels}" \
            >> ${D}${sysconfdir}/demo-wifi/hostapd.conf
        # Used when ACS fails to start the AP (see demo-wifi-ap-run)
        channel="${WIFI_ACS_FALLBACK:-$fallback_channel}"
        case "$channel" in
        *[!0-9]* | "") bbfatal "wifi.conf: WIFI_ACS_FALLBACK must be a channel number" ;;
        esac
        subst ${UNPACKDIR}/demo-wifi-ap.hostapd.conf ${D}${sysconfdir}/demo-wifi/hostapd-fallback.conf
        chmod 0600 ${D}${sysconfdir}/demo-wifi/hostapd-fallback.conf
    fi
    chmod 0600 ${D}${sysconfdir}/demo-wifi/hostapd.conf
    install -D -m 0755 ${UNPACKDIR}/demo-wifi-ap-run ${D}${libexecdir}/demo-wifi/demo-wifi-ap-run

    install -d ${D}${systemd_system_unitdir}
    subst ${UNPACKDIR}/demo-wifi-ap.service ${D}${systemd_system_unitdir}/demo-wifi-ap.service
    subst ${UNPACKDIR}/demo-wifi-dhcp.service ${D}${systemd_system_unitdir}/demo-wifi-dhcp.service
    subst ${UNPACKDIR}/demo-wifi-mdns.service ${D}${systemd_system_unitdir}/demo-wifi-mdns.service
    install -d ${D}${sysconfdir}/dnsmasq.d
    subst ${UNPACKDIR}/demo-wifi-dnsmasq.conf ${D}${sysconfdir}/dnsmasq.d/demo-wifi

    install -d ${D}${sysconfdir}/NetworkManager/conf.d
    subst ${UNPACKDIR}/demo-wifi-ap-unmanaged.conf \
        ${D}${sysconfdir}/NetworkManager/conf.d/demo-wifi-ap-unmanaged.conf
}

# Ship only our files: networkmanager-daemon owns its directories, and rpm
# rejects two packages owning one directory with different attributes.
FILES:${PN} = " \
    ${nonarch_libdir}/NetworkManager/system-connections/demo-wifi-client.nmconnection \
    ${sysconfdir}/demo-wifi \
    ${sysconfdir}/NetworkManager/conf.d/demo-wifi-ap-unmanaged.conf \
    ${sysconfdir}/dnsmasq.d/demo-wifi \
    ${systemd_system_unitdir}/demo-wifi-*.service \
    ${libexecdir}/demo-wifi \
    ${datadir}/demo-wifi \
    ${nonarch_base_libdir}/udev/rules.d/70-wlan-mac.rules \
    ${nonarch_libdir}/systemd/resolved.conf.d/50-demo-wifi.conf \
"
RDEPENDS:${PN} = "networkmanager networkmanager-wifi"
RDEPENDS:${PN}:append:uno-q = " iproute2 coreutils"
RDEPENDS:${PN}:append:iq-9075-evk = " iproute2 coreutils"
RDEPENDS:${PN}:append:ventuno-q = " hostapd dnsmasq iproute2 avahi-daemon avahi-utils"

# /etc/hosts belongs to the base packages: add the server name to it at
# image build time (idempotent, so it also works when run on the target).
pkg_postinst:${PN}() {
    entry="$(cat $D${datadir}/demo-wifi/hosts)"
    grep -qxF "$entry" $D${sysconfdir}/hosts 2>/dev/null || echo "$entry" >> $D${sysconfdir}/hosts
}
