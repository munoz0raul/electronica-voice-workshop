SUMMARY = "Foundries update-server for the demo fleet"
DESCRIPTION = "Builds fioserver from source and runs it as a host systemd \
service on the VENTUNO Q. It is not a compose app: the OTA components it \
manages would otherwise restart it during its own rollouts."
HOMEPAGE = "https://github.com/foundriesio/update-server"
LICENSE = "BSD-3-Clause-Clear"
LIC_FILES_CHKSUM = "file://src/${GO_IMPORT}/LICENSE.txt;md5=626b8c5a0b1760b8d0479a6456a43cad"

SRC_URI = " \
    git://github.com/foundriesio/update-server;protocol=https;branch=main;destsuffix=${GO_SRCURI_DESTSUFFIX} \
    file://fioserver.service \
    file://fioserver-init.service \
"
SRCREV = "0af7868c4356234e953bec004e3078cc12ca4a5a"
PV = "1.0~rc3+git"

# Go modules and their licenses, generated by "bitbake -c update_modules
# update-server" (go-mod-update-modules). Rerun it after moving SRCREV.
require ${BPN}-go-mods.inc
require ${BPN}-licenses.inc

# go.mod needs Go 1.27.3 or later; ventuno-q.yml adds the meta-lts-mixins
# wrynose/go layer for it.
GO_IMPORT = "github.com/foundriesio/update-server"
GO_INSTALL = "${GO_IMPORT}/cmd/server"

# "git describe --tags" of SRCREV; upstream's Makefile sets it the same way.
# The server reports it and uses it to cache-bust its web UI assets.
UPDATE_SERVER_VERSION = "v1.0-rc3-24-g0af7868"
GO_EXTRA_LDFLAGS += "-X=${GO_IMPORT}/version.Version=${UPDATE_SERVER_VERSION}"

COMPATIBLE_MACHINE = "^ventuno-q$"

# All server state: devices, updates, configs, users, PKI and TUF keys. /var
# is preserved across OSTree deployments, so OS updates keep it.
UPDATE_SERVER_DATADIR ?= "${localstatedir}/local/datadir"

# "1": initialize an empty datadir on first boot with devserver-init (admin/
# admin login). "0": provision it by hand or restore a backup.
UPDATE_SERVER_AUTO_INIT ?= "1"
# Name devices reach the gateway by; it goes in the gateway's TLS certificate
UPDATE_SERVER_DNS_NAME ?= "demo-server.local"
# API requests per second per client IP, set in a new datadir's auth config
UPDATE_SERVER_API_RATE_LIMIT ?= "100"

inherit go-mod go-mod-update-modules systemd
SYSTEMD_SERVICE:${PN} = "fioserver.service ${@'fioserver-init.service' if d.getVar('UPDATE_SERVER_AUTO_INIT') == '1' else ''}"
SYSTEMD_AUTO_ENABLE = "enable"

# Installs only the server binary, renamed fioserver as in upstream's Makefile
do_install() {
    install -D -m 0755 ${B}/${GO_BUILD_BINDIR}/server ${D}${bindir}/fioserver
    install -d ${D}${systemd_system_unitdir}
    units="fioserver.service"
    if [ "${UPDATE_SERVER_AUTO_INIT}" = "1" ]; then
        units="$units fioserver-init.service"
    fi
    for unit in $units; do
        sed -e 's|@BINDIR@|${bindir}|g' \
            -e 's|@DATADIR@|${UPDATE_SERVER_DATADIR}|g' \
            -e 's|@DNS_NAME@|${UPDATE_SERVER_DNS_NAME}|g' \
            -e 's|@API_RATE_LIMIT@|${UPDATE_SERVER_API_RATE_LIMIT}|g' \
            ${UNPACKDIR}/$unit > ${D}${systemd_system_unitdir}/$unit
    done
}
